Commit message: Added Movement
v1

File: arm.urdf (robot description, URDF)
Before this commit: robot Arm, 6 links, 5 joints
Links:
- link base: geometry collision box size=0.5 5 5; visual box size=0.5 5 7
- link tube: mass 11 -> 15; geometry collision box size=2 0.5 3; visual box size=2 0.5 3
